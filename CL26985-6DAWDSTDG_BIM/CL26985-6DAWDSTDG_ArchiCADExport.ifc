Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-09-19T16:40:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Alternate UI 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 19 16:40:57 2022 * Host: DESKTOP-H3C3U9I * Database: C:\Users\nawap\AppData\Local\Temp\4a25d9b6-c1e9-4540-a264-505962b7e589\933de518-194d-4938-acaa-40c46fa4b96b\ifc * Database version: 5507 * Database creation date: Mon Sep 19 16:40:55 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 19 16:40:55 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 19 16:40:55 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:Story Level, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_ProductRequirements - Name: Level 1; Category: Levels
Pset_AirSideSystemInformation - Name: Level 1

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_283145 | SINK
Port_283145 | SOURCE

# IfcFlowTerminal: CL26985-6DAWDSTDG_REVIT:Winplus ll Dual Top 3/4.5L Slow SC W WT, CL26985-6DAWDSTDG_REVIT:Winplus ll Dual Top 3/4.5L Slow SC W WT:283145
In: Level 1
Material: Ceramic, Chrome
Pset_DistributionFlowElementCommon - Reference: Winplus ll Dual Top 3/4.5L Slow SC W WT; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Pset_ProductRequirements - Category: Plumbing Fixtures
